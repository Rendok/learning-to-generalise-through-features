Commit message: New observation space

File: examples/pybullet/utils/models/sink.urdf (robot description, URDF)
Before this commit: robot sink, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.25 0.25 0.005; visual box size=0.25 0.25 0.005
